# Keil uVision project STM32U5G9J_DK2_HSPI.uvprojx, settings and files
target STM32U5G9J_DK2_HSPI (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: MX66LM1G45G_STM32U5G9J-DK2
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM,USE_HAL_DRIVER,USE_IOEXPANDER, CORE_CM33,STM32U5G9xx
  c include: .\HSPI;.\HSPI\Components\mx66uw1g45g;.\HSPI\CMSIS;.\HSPI\STM32U5G9J-DK2;.\HSPI\STM32U5xx_HAL_Driver\Inc;.\RTE\_STM32U599J-DK;.\RTE\Device\ARMCM33
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group HSPI
    ./HSPI/: STM32U5HSPI.c
    ./HSPI/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_xspi.c stm32u5xx_ll_dlyb.c
    ./HSPI/STM32U5G9J-DK2/: stm32u5g9j_discovery_hspi.c
    ./HSPI/Components/mx66uw1g45g/: mx66uw1g45g.c
    ./HSPI/CMSIS/: system_stm32u5xx.c
