# Keil uVision project SensorProj.uvprojx, settings and files
target SensorProj (6160000::V6.16::ARMCLANG)
  device: STM32U575RITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: SensorProj +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx,UX_STANDALONE,UX_INCLUDE_USER_DEFINE_FILE
  c include: ../Core/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include/;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/;../Middlewares/Third_Party/CMSIS/RTOS2/Include/;../Middlewares/Third_Party/FatFs/src;../Middlewares/ST/usbx/common/core/inc;../Middlewares/ST/usbx/common/usbx_device_classes/inc;../Middlewares/ST/usbx/common/usbx_stm32_device_controllers;../Middlewares/ST/usbx/ports/generic/inc;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/SensorStreaming_WCID/Inc;../USBX/App;../USBX/Target;..\HQYJ-BSP\Inc;..\BSP\Sensor\Inc
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c icache.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c usart.c key_adc.c dma_sampling.c acq_config.c sensor_bin.c frame_ring.c i2c.c app_time.c rtc_pcf85063.c sai.c es8311.c mic_capture.c battery_adc.c
    ../Core/Inc/: key_adc.h dma_sampling.h
  group Application/User/Storage
    ../Core/Src/: sdmmc.c sd_diskio.c fatfs_sd.c device_config.c
    ../Core/Inc/: sdmmc.h sd_diskio.h fatfs_sd.h sensor_snapshot.h device_config.h
  group Application/User/USB
    ../Core/Src/: usb_otg.c ux_standalone_port.c boot_mode.c board_io.c user_ctrl.c usb_pcd_dispatch.c usb_msc_app.c usbd_conf.c usbd_desc.c usbd_storage_if.c
    ../Core/Inc/: usb_otg.h boot_mode.h usb_pcd_dispatch.h usb_msc_app.h usbd_conf.h usbd_desc.h usbd_storage_if.h
    ../USBX/App/: app_usbx_device.c app_usbx_device.h ux_device_descriptors.c ux_device_descriptors.h ux_device_cdc_acm.c ux_device_cdc_acm.h ux_user.h
    ../USBX/Target/: ux_stm32_config.h
  group Middlewares/USBD_Classic/Core
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USBD_Classic/MSC
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/SensorStreaming_WCID/Src/: usbd_wcid_streaming.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/SensorStreaming_WCID/Inc/: usbd_wcid_streaming.h
  group Middlewares/USBX/Core
    ../Middlewares/ST/usbx/common/core/src/: ux_system_initialize.c ux_system_error_handler.c ux_device_stack_initialize.c ux_device_stack_class_register.c ux_device_stack_tasks_run.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_disconnect.c ux_utility_memory_allocate.c ux_utility_memory_free.c ux_utility_memory_copy.c ux_utility_memory_set.c ux_utility_memory_compare.c ux_utility_memory_byte_pool_create.c ux_utility_descriptor_parse.c ux_utility_descriptor_pack.c ux_utility_short_get.c ux_utility_short_put.c ux_utility_long_get.c ux_utility_long_put.c ux_utility_string_length_check.c ux_utility_memory_byte_pool_search.c ux_utility_memory_allocate_mulc_safe.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_set_feature.c ux_device_stack_interface_delete.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_system_tasks_run.c
  group Middlewares/USBX/CDC_ACM
    ../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_cdc_acm_entry.c ux_device_class_cdc_acm_initialize.c ux_device_class_cdc_acm_unitialize.c ux_device_class_cdc_acm_activate.c ux_device_class_cdc_acm_deactivate.c ux_device_class_cdc_acm_control_request.c ux_device_class_cdc_acm_tasks_run.c ux_device_class_cdc_acm_read_run.c ux_device_class_cdc_acm_write_run.c ux_device_class_cdc_acm_ioctl.c
  group Middlewares/USBX/STM32_DCD
    ../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_initialize.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_callback.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_uninitialize.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_icache.c stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_ll_usb.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/HQYJ-BSP
    ../HQYJ-BSP/Src/: user_app.c
  group BSP/Sensor
    ../BSP/Sensor/Src/: bsp_spi.c lsm6dsox.c qma6100p.c h3lis100dl.c lis2mdl.c aht20.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff.h diskio.c diskio.h ffconf.h integer.h
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c
software components: CMSIS:CORE 4.3.0
